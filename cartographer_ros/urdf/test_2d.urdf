Commit message: fix bug

File: cartographer_ros/urdf/test_2d.urdf (robot description, URDF)
Before this commit: robot cartographer_backpack_2d, 3 links, 2 joints
Joints:
- joint horizontal_laser_link_joint: origin xyz=0. 0. 0. -> xyz=-0.11 0.085 -0.115 rpy=0 3.141592654 1.570796327
